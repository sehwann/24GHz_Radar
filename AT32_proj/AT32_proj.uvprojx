# Keil uVision project AT32_proj.uvprojx, settings and files
target AT32_petabrew (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413RCT7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32_proj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F413Rx_HD,USE_STDPERIPH_DRIVER,AT_START_F413_V1_0
  c include: ..\inc;..\src;..\AT32_proj;.\distance_wide
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Drivers/BSP
    ../src/: at32_board.c
  group Drivers/CMSIS
    ../src/: system_at32f4xx.c startup_at32f413rx_hd.s
  group User
    ../src/: main.c
    ./: general.c general.h main_at32f4xx.c main_at32f4xx.h
  group SC1233
    ./SC1233/: main_sc123x.h rs_ctl_base.c rs_ctl_base.h rs_ctl_cmd.c rs_ctl_cmd.h rs_ctl_dev.c rs_ctl_dev.h rs_ctl_distance.c rs_ctl_distance.h rs_ctl_setup.c rs_ctl_setup.h rs_dev_addr.h rs_dev_opcode.h rs_handle.h rs_types.h sc123x_gpio.c sc123x_gpio.h
  group Drivers/AT32Periph
    ../src/: at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_usart.c misc.c at32f4xx_adc.c at32f4xx_dma.c
  group Source/FreeRTOS
    ../src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group distance
    ./distance_wide/: all.h distance_wide_fine_40db_220us.h distance_wide_fine_40db_1100us.h distance_wide_fine_40db_4400us.h distance_wide_fine_50db_220us.h distance_wide_fine_50db_1100us.h distance_wide_fine_50db_4400us.h distance_wide_fine_60db_220us.h distance_wide_fine_60db_1100us.h distance_wide_fine_60db_4400us.h distance_wide_normal_40db_220us.h distance_wide_normal_40db_1100us.h distance_wide_normal_40db_4400us.h distance_wide_normal_50db_220us.h distance_wide_normal_50db_1100us.h distance_wide_normal_50db_4400us.h distance_wide_normal_60db_220us.h distance_wide_normal_60db_1100us.h distance_wide_normal_60db_4400us.h distance_wide_xfine_40db_220us.h distance_wide_xfine_40db_1100us.h distance_wide_xfine_50db_220us.h distance_wide_xfine_50db_1100us.h distance_wide_xfine_60db_220us.h distance_wide_xfine_60db_1100us.h
